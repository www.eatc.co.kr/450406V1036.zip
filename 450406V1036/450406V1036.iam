# Autodesk Inventor assembly: 450406V1036
## iProperties
Created: 2015-04
Part Number: 450406V1036
Document SubType Name: Assembly
Designer: elite
Author: elite
