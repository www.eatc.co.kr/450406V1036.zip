# Autodesk Inventor part: 450406V1036
## iProperties
Created: 2015-04
Part Number: 450406V1036
Document SubType Name: Modeling
Designer: elite
Density: 1 g/cm^3
Author: elite
